# Keil uVision project plooc_example.uvprojx, settings and files
target arm_compiler_6_example (6240000::V6.24::.\ArmCompilerforEmbedded6.24)
  device: ARMCM3 ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: plooc_example
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=5 wLevel=2
  c include: ..\mdk;..\..\..\example;..\..\trace;..\..\byte_queue;..\..\enhanced_byte_queue
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\ARMCM3\ARMCM3_ac6.sct
  group platform
    ./: platform.c platform.h
    ../: main.c
  group byte_queue
    ../../byte_queue/: byte_queue.h byte_queue.c
  group enhanced_byte_queue
    ../../enhanced_byte_queue/: enhanced_byte_queue.c enhanced_byte_queue.h
  group trace
    ../../trace/: trace.h trace.c
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Event Recorder 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, Device:Startup 2.2.0, Language Extension:PLOOC 4.6.5
